# Keil uVision project Project.uvprojx, settings and files
target stm32f103-led (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103-msh +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: libraries/STM32F1xx_HAL_Driver/Inc;libraries/STM32F1xx_HAL_Driver/Inc/Legacy;libraries/CMSIS/Device/ST/STM32F1xx/Include;libraries/CMSIS/Include;.\drivers;.\hardware;.\applications;.\USMART
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3f000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Applications
    applications/: main.c
    ./applications/: main_control.c menu.c
  group STM32-HAL
    ./libraries/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s startup_stm32f103xb.s
    libraries/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c
    libraries/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
    ./libraries/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_spi.c stm32f1xx_hal_msp.c stm32f1xx_hal_i2c.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c
  group HARDWARE
    ./hardware/: button.c led_595.c iic_bus.c 24cxx.c TOF10120.c usart1.c usart2.c usart3.c usart2_ctl.c usart3_ctl.c pwm_tim3.c pwm_tim4.c pwm_ctl.c spi_bus.c 24l01.c flash_eeprom.c oled.c sm4.c cd4051.c adc.c myiic.c LM75A.c
  group USMART
    ./USMART/: db.c db_config.c db_str.c
software components: CMSIS:CORE 3.40.0, RTOS:kernel 3.1.3, RTOS:shell 3.1.3
